File: 2.5-hdd_box/top_cover.kicad_pcb (KiCad board)
At the start: 2 copper layers, 120 x 105.4 mm, 6 parts

Commit message: small correction for last order
Other:
- board text added: "AgOObox v1.0"
